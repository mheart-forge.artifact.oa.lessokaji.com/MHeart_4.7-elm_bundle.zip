*HEADING
MHeart 4.2-basalt coarse component thermal case
*NODE,NSET=ALLN
1,0.028,0,0
2,0.02746198785,0.005462529016,0
3,0.02586862691,0.01071513611,0
4,0.02328114914,0.01555596652,0
5,0.01979898987,0.01979898987,0
6,0.01555596652,0.02328114914,0
7,0.01071513611,0.02586862691,0
8,0.005462529016,0.02746198785,0
9,1.714505519e-18,0.028,0
10,-0.005462529016,0.02746198785,0
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*ELEMENT,TYPE=C3D8,ELSET=WALL
1,1,33,34,2,129,161,162,130
2,2,34,35,3,130,162,163,131
3,3,35,36,4,131,163,164,132
4,4,36,37,5,132,164,165,133
5,5,37,38,6,133,165,166,134
6,6,38,39,7,134,166,167,135
7,7,39,40,8,135,167,168,136
8,8,40,41,9,136,168,169,137
9,9,41,42,10,137,169,170,138
10,10,42,43,11,138,170,171,139
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*NSET,NSET=HOT
1,2,3,4,5,6,7,8,9,10,11,12
13,14,15,16,17,18,19,20,21,22,23,24
25,26,27,28,29,30,31,32,33,34,35,36
37,38,39,40,41,42,43,44,45,46,47,48
49,50,51,52,53,54,55,56,57,58,59,60
61,62,63,64,65,66,67,68,69,70,71,72
73,74,75,76,77,78,79,80,81,82,83,84
85,86,87,88,89,90,91,92,93,94,95,96
97,98,99,100,101,102,103,104,105,106,107,108
109,110,111,112,113,114,115,116,117,118,119,120
121,122,123,124,125,126,127,128
*NSET,NSET=COLD
5121,5122,5123,5124,5125,5126,5127,5128,5129,5130,5131,5132
5133,5134,5135,5136,5137,5138,5139,5140,5141,5142,5143,5144
5145,5146,5147,5148,5149,5150,5151,5152,5153,5154,5155,5156
5157,5158,5159,5160,5161,5162,5163,5164,5165,5166,5167,5168
5169,5170,5171,5172,5173,5174,5175,5176,5177,5178,5179,5180
5181,5182,5183,5184,5185,5186,5187,5188,5189,5190,5191,5192
5193,5194,5195,5196,5197,5198,5199,5200,5201,5202,5203,5204
5205,5206,5207,5208,5209,5210,5211,5212,5213,5214,5215,5216
5217,5218,5219,5220,5221,5222,5223,5224,5225,5226,5227,5228
5229,5230,5231,5232,5233,5234,5235,5236,5237,5238,5239,5240
5241,5242,5243,5244,5245,5246,5247,5248
*MATERIAL,NAME=HAYNES230
*CONDUCTIVITY
8.9,298.15
10.4,373.15
12.4,473.15
14.4,573.15
16.4,673.15
18.4,773.15
20.4,873.15
22.4,973.15
24.4,1073.15
*SOLID SECTION,ELSET=WALL,MATERIAL=HAYNES230
*INITIAL CONDITIONS,TYPE=TEMPERATURE
ALLN,313.15
*STEP,INC=100
*HEAT TRANSFER,STEADY STATE
1,1
*BOUNDARY
HOT,11,11,1023.15
COLD,11,11,313.15
*NODE FILE
NT,RFL
*EL FILE
HFL
*NODE PRINT,NSET=HOT,TOTALS=YES
RFL
*NODE PRINT,NSET=COLD,TOTALS=YES
RFL
*END STEP
