*HEADING
MHeart 4.2-basalt fine component thermal case
*NODE,NSET=ALLN
1,0.028,0,0
2,0.02786517235,0.002744479929,0
3,0.02746198785,0.005462529016,0
4,0.0267943294,0.008127970963,0
5,0.02586862691,0.01071513611,0
6,0.0246937954,0.01319910863,0
7,0.02328114914,0.01555596652,0
8,0.02164429269,0.01776301196,0
9,0.01979898987,0.01979898987,0
10,0.01776301196,0.02164429269,0
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*ELEMENT,TYPE=C3D8,ELSET=WALL
1,1,65,66,2,385,449,450,386
2,2,66,67,3,386,450,451,387
3,3,67,68,4,387,451,452,388
4,4,68,69,5,388,452,453,389
5,5,69,70,6,389,453,454,390
6,6,70,71,7,390,454,455,391
7,7,71,72,8,391,455,456,392
8,8,72,73,9,392,456,457,393
9,9,73,74,10,393,457,458,394
10,10,74,75,11,394,458,459,395
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*NSET,NSET=HOT
1,2,3,4,5,6,7,8,9,10,11,12
13,14,15,16,17,18,19,20,21,22,23,24
25,26,27,28,29,30,31,32,33,34,35,36
37,38,39,40,41,42,43,44,45,46,47,48
49,50,51,52,53,54,55,56,57,58,59,60
61,62,63,64,65,66,67,68,69,70,71,72
73,74,75,76,77,78,79,80,81,82,83,84
85,86,87,88,89,90,91,92,93,94,95,96
97,98,99,100,101,102,103,104,105,106,107,108
109,110,111,112,113,114,115,116,117,118,119,120
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*NSET,NSET=COLD
30721,30722,30723,30724,30725,30726,30727,30728,30729,30730,30731,30732
30733,30734,30735,30736,30737,30738,30739,30740,30741,30742,30743,30744
30745,30746,30747,30748,30749,30750,30751,30752,30753,30754,30755,30756
30757,30758,30759,30760,30761,30762,30763,30764,30765,30766,30767,30768
30769,30770,30771,30772,30773,30774,30775,30776,30777,30778,30779,30780
30781,30782,30783,30784,30785,30786,30787,30788,30789,30790,30791,30792
30793,30794,30795,30796,30797,30798,30799,30800,30801,30802,30803,30804
30805,30806,30807,30808,30809,30810,30811,30812,30813,30814,30815,30816
30817,30818,30819,30820,30821,30822,30823,30824,30825,30826,30827,30828
30829,30830,30831,30832,30833,30834,30835,30836,30837,30838,30839,30840
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*MATERIAL,NAME=HAYNES230
*CONDUCTIVITY
8.9,298.15
10.4,373.15
12.4,473.15
14.4,573.15
16.4,673.15
18.4,773.15
20.4,873.15
22.4,973.15
24.4,1073.15
*SOLID SECTION,ELSET=WALL,MATERIAL=HAYNES230
*INITIAL CONDITIONS,TYPE=TEMPERATURE
ALLN,313.15
*STEP,INC=100
*HEAT TRANSFER,STEADY STATE
1,1
*BOUNDARY
HOT,11,11,1023.15
COLD,11,11,313.15
*NODE FILE
NT,RFL
*EL FILE
HFL
*NODE PRINT,NSET=HOT,TOTALS=YES
RFL
*NODE PRINT,NSET=COLD,TOTALS=YES
RFL
*END STEP
